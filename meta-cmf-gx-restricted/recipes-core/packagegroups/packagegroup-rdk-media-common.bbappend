RDEPENDS_packagegroup-rdk-media-common_remove = "\
    closedcaption \
    servicemanagerfunctionaltest \
"

RDEPENDS_packagegroup-rdk-media-common_append_hybrid = "\
    fog \
    sessionmgr \
    subttxrend-app \
    subttxrend-cc \
    subttxrend-common \
    subttxrend-dbus \
    subttxrend-dvbsub \
    subttxrend-gfx \
    subttxrend-protocol \
    subttxrend-scte \
    subttxrend-socksrc \
    subttxrend-testapps \
    subttxrend-ttml \
    subttxrend-ttxt \
    subttxrend-webvtt \
"
