SRC_URI = "${CMF_GIT_ROOT}/devices/intel-x86-pc/rdkri/mediaframework;protocol=${CMF_GIT_PROTOCOL};branch=${CMF_GIT_BRANCH}"
SRCREV = "${AUTOREV}"

