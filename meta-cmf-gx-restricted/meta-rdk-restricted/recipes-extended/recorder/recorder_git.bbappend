CXXFLAGS += "-DTRH_DISABLE"
