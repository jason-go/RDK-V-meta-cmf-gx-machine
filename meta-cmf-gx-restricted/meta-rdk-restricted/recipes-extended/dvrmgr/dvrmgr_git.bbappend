EXTRA_OECONF_remove_hybrid = " --enable-ippvsource --enable-rbi --enable-sdv --enable-xfs"
