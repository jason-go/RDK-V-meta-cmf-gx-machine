# enable RPI SOC implementation for subtecfilter
EXTRA_OECONF = " --enable-soc-rpi=yes"
