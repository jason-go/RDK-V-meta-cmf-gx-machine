EXTRA_QMAKEVARS_PRE += "DEFINES+=HAS_API_HOME_NETWORKING"
