FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_rpi = "file://psplash-gx-img.h;outsuffix=gx"
