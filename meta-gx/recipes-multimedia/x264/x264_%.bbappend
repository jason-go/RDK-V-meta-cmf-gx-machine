EXTRA_OECONF_append_gx = " --disable-asm"
