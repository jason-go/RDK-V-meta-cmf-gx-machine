SRC_URI_remove = "git://github.com/google/protobuf.git;branch=3.11.x"
SRC_URI += "git://github.com/protocolbuffers/protobuf.git"
