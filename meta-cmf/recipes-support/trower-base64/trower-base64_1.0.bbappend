SRC_URI_remove = "git://github.com/Comcast/trower-base64.git;branch=main"
SRC_URI += "git://github.com/Comcast/trower-base64.git;protocol=https;branch=main"
