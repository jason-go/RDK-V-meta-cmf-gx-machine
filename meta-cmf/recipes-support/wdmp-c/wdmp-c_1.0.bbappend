SRC_URI_remove = "git://github.com/Comcast/wdmp-c.git"
SRC_URI += "git://github.com/Comcast/wdmp-c.git;protocol=https;branch=master"
