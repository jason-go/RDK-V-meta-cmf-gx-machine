SRC_URI_remove = "git://github.com/xmidt-org/parodus.git"
SRC_URI += "git://github.com/xmidt-org/parodus.git;protocol=https;branch=master"
