SRC_URI_remove = "git://github.com/libtom/libtomcrypt.git;branch=develop"
SRC_URI += "git://github.com/libtom/libtomcrypt.git;branch=develop;protocol=https"
