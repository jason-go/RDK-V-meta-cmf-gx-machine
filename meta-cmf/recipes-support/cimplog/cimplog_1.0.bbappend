SRC_URI_remove = "git://github.com/Comcast/cimplog.git"
SRC_URI += "git://github.com/Comcast/cimplog.git;protocol=https;branch=master"
