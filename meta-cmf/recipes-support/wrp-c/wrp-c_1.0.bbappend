SRC_URI_remove = "git://github.com/Comcast/wrp-c.git"
SRC_URI += "git://github.com/Comcast/wrp-c.git;protocol=https;branch=master"
