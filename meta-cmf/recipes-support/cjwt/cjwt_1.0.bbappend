SRC_URI_remove = "git://github.com/Comcast/cjwt.git"
SRC_URI += "git://github.com/Comcast/cjwt.git;protocol=https;branch=master"

