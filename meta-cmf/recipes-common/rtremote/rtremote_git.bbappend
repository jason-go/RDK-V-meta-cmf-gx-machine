SRC_URI_remove = "git://github.com/rdkcentral/rtRemote;branch=release"
SRC_URI += "git://github.com/rdkcentral/rtRemote;protocol=https;branch=release"

inherit coverity
