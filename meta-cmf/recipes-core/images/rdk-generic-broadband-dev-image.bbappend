IMAGE_INSTALL_remove = "jst"
