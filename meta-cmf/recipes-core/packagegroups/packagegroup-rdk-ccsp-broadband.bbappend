LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " ccsp-epon-agent"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " ccsp-logagent"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " ccsp-xconf"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " dcmjsonparser"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdm"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " memstress"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " mesh-agent"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " notify-comp"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " harvester"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " ovs-agent"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " powermgr"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " ipoe-health-check"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " json-hal-lib"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdkgponmanager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdkxdslmanager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdk-wanmanager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdktelcovoicemanager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdk-vlanmanager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdk-ppp-manager"
RDEPENDS_packagegroup-rdk-ccsp-broadband_append = " rdk-fwupgrade-manager"
