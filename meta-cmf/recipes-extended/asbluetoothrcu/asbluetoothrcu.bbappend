inherit coverity

# Unpin the SRCREV to build tip
SRCREV_blercudaemon = "${AUTOREV}"
